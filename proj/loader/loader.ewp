# IAR project loader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RE ST STM32F103RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: _DEBUG; _LOADER; JLINK_RTT_TRACE; STM32F10X_HD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\src\Chip\PeriphDriver\inc; ..\..\src\Chip\STM32F10x\CMSIS; ..\..\src\Chip\STM32F10x\Comm\inc; ..\..\src\Chip\STM32F10x\STM32F10x_StdPeriph_Driver\inc; ..\..\src\Comm\utlis\inc; ..\..\src\Comm\utlis\inc\trace; ..\..\src\Comm\utlis\inc\trace\RTT; ..\..\src\Comm\Param\inc; ..\..\src\Comm\core\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: loader.hex
  ILINK.IlinkOutputFile: cc.out
  ILINK.IlinkIcfFile: ..\..\src\Chip\STM32F10x\CMSIS\Linker\Boot.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
  ICCARM.CCDefines: NDEBUG; _LOADER; STM32F10X_HD; USE_STDPERIPH_DRIVER
  group app
    ./: AppCore.c main.c
  group chip/STM32F10x
    ./: stm32f10x_conf.h
  group chip/STM32F10x/CMSIS
    ../../src/Chip/STM32F10x/CMSIS/iar/: startup_stm32f10x_hd.s
    ../../src/Chip/STM32F10x/CMSIS/: stm32f10x_it.c system_stm32f10x.c
  group chip/STM32F10x/Comm
    ../../src/Chip/STM32F10x/Comm/src/: GPIO.c StartUpCfg.c
  group chip/STM32F10x/STM32F10x_StdPeriph_Driver
    ../../src/Chip/STM32F10x/STM32F10x_StdPeriph_Driver/src/: STM32F10xStdPeriphLib.a
  group comm/utils
    ../../src/Comm/utlis/src/: FSMBuffer.c
  group comm/utils/libs
    ../../src/Comm/utlis/src/: crc.c libs.c utils.c
  group comm/utils/trace
    ../../src/Comm/utlis/src/trace/: trace.c
  group comm/utils/trace/RTT
    ../../src/Comm/utlis/src/trace/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
