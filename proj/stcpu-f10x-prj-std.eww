<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\loader\loader.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\iar-mdk\Template.ewp</path>
    </project>
    <batchBuild />
</workspace>
